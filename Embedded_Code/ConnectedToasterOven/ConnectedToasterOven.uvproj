# Keil uVision project ConnectedToasterOven.uvproj, settings and files
target ML56SD1AE (MCS-51)
  device: ML56SD1AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0xFFFF)  XRAM(0 - 0xFFF) CLOCK(24000000)
  output: ConectedToasterOven +hex
  c flags: Optimize=9
  c include: .\Library
  link misc: REMOVEUNUSED
  group Source Files
    ./Source/: Bsp.c BspConfig.c Com.c CommandParser.c Control.c Main.c Utility.c TemperatureControl.c Tune.c LCD.c Quadrature.c CloudCommandParser.c CloudCommandParserUnitTests.c
  group Library Files
    ./Library/: Function_Define_ML56.h gpio.c gpio.h ML56.h ML56_XSFR.c ML56_XSFR.h SFR_Macro_ML56.h sys.c sys.h
  group Startup
    ./: STARTUP.A51
  group Header Files
    ./Source/: Bsp.h BspConfig.h Com.h CommandParser.h Control.h Utility.h TemperatureControl.h Tune.h LCD.h Quadrature.h CloudCommandParser.h
